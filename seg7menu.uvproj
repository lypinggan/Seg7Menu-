# Keil uVision project seg7menu.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: seg7menu +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\src;.\src\os
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./src/: key.c Menu.c menu_00.c menu_01.c menu_02.c menu_03.c Message.c SegDynamicScan.c
    ./src/os/: SYSOS.c
